v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {gate_driver_LDS.sym} 10 -10 0 0 {name=x1}
