v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {brad_VI_input_LDS.sym} -250 90 0 0 {name=x1}
C {bias_gen_LDS.sym} -490 -70 0 0 {name=x2}
