v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {cascode_bias_lds.sym} -30 30 0 0 {name=x1}
