v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
C {cascoded_opamp.sym} 0 10 0 0 {name=x1}
C {sky130_fd_pr/corner.sym} -320 60 0 0 {name=CORNER only_toplevel=false corner=tt}
C {code_shown.sym} -280 -130 0 0 {name=SPICE only_toplevel=false value=blabla}
